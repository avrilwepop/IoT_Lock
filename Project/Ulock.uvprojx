# Keil uVision project Ulock.uvprojx, settings and files
target Ulcok (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ulock +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L1XX_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\startup;..\CMSIS;..\FWlib\inc;..\FWlib\src;..\User;..\User\key;..\User\lcd;..\User\led;..\User\spi;..\User\systick;..\User\timer;..\User\usart;..\User\global;..\User\gprs;..\User\bsp_ctr;..\User\GPS;..\User\rfid;..\User\serial;..\User\lp_mode;..\User\common;..\User\LM;..\User\eeprom
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../User/: main.c stm32l1xx_it.c
    ../User/systick/: systick.c
    ../User/timer/: timer.c
    ../User/usart/: usart.c
    ../User/key/: key.c
    ../User/lcd/: lcd.c
    ../User/global/: global.c
    ../User/gprs/: gprs.c BSprotocol.c
    ../User/bsp_ctr/: bsp_ctr.c
    ../User/GPS/: gps.c
    ../User/rfid/: rfid.c
    ../User/serial/: serial.c
    ../User/lp_mode/: lp_mode.c
    ../User/common/: CRCEncoder.c common.c
    ../User/LM/: TTLM.c
    ../User/eeprom/: eeprom.c i2c.c
  group fwlib
    ../FWlib/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group startup
    ../CMSIS/startup/: startup_stm32l1xx_mdp.s
  group cmsis
    ../CMSIS/: system_stm32l1xx.c
